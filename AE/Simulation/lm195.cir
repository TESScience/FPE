* gnetlist -g spice-noqsi -m ../Schematic/censor-fix.scm -o lm195.cir lm195.sch
* SPICE file generated by spice-noqsi version 20130710
* Send requests or bug reports to jpd@noqsi.com
.SUBCKT lm195 c b e
Q1 e b1 b2 latpnp
Q2 c b2 b3 vertnpn
D1 e c dnd
R1 b b1 500
R2 1 b3 500
Q3 c b3 1 vertnpn m=25
R3 e 1 0.1
*
*
*
Crt c b2 4pF
Ib c b2 DC 0.2mA
.ENDS
